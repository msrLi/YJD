# Keil uVision project wifi.uvproj, settings and files
target mcu_wifi (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: wifi +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT=1,ARM_MATH_CM4,STM32F4XX
  c include: ..\bsp\stm32f4xx\FWlib4xx\inc;..\kernel\ucos\include;..\bsp\stm32f4xx\CMSIS\inc;..\net\lwip\src\include\ipv4;..\net\lwip\src\include;..\net\lwip\src\arch;..\net\lwip\src;..\kernel\api\inc;..\app\inc;..\jpeg\jpeg-9a;..\net\udhcp-0.9.8;..\libmad-0.15.1b;..\net\libertas\inc;..\net\wpa;..\net\wlan_src\mlan;..\net\wlan_src\mlinux;..\net\wlan_src\user;..\net\wlan_src\mapp;..\net\wlan_src\mapp\wifidirectutl;..\ZQWL_ETH_APP;..\app\inc;..\drivers\stm32f4xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --remove
  group STM32F4xx_StdPeriph_Driver
    ../bsp/stm32f4xx/FWlib4xx/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_iwdg.c
  group CMSIS
    ../bsp/stm32f4xx/CMSIS/src/: system_stm32f4xx.c
    ../bsp/stm32f4xx/CMSIS/inc/: startup_stm32f4xx.s
  group drivers
    ../drivers/stm32f4xx/src/: sdcard.c w25p80.c driver_misc.c parallel.c exti.c
  group os
    ../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../kernel/api/src/: atomic.c mbox.c msg_q.c mutex.c sem.c task.c timer.c wait.c memory.c
  group lwip_api
    ../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../net/lwip/src/netif/: ethernetif.c etharp.c
  group udhcp
    ../net/udhcp-0.9.8/: dhcpd.c leases.c options.c packet.c serverpacket.c
  group muser
    ../net/wlan_src/user/: skbuff.c usr_cfg.c
  group mlinux
    ../net/wlan_src/mlinux/: moal_cfg80211.c moal_debug.c moal_ioctl.c moal_main.c moal_proc.c moal_sdio_mmc.c moal_shim.c moal_sta_cfg80211.c moal_uap.c moal_uap_cfg80211.c moal_uap_priv.c
  group mlan
    ../net/wlan_src/mlan/: mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_init.c mlan_join.c mlan_meas.c mlan_misc.c mlan_module.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_sta_tx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_uap_txrx.c mlan_wmm.c mlan_11d.c
  group app
    ../app/src/: main.c LED.C test_wifi.c sys_misc.c SCI.c LED_Ctrl.C task_parallet.c TCP_CLient.C
  group ZQWL_ETH_APP
    ../ZQWL_ETH_APP/: ZQWL_ETH_APP.lib
